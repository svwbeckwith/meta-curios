SRC_URI = "git://github.com/lz4/lz4.git;protocol=https;branch=dev \
           file://0001-tests-Makefile-don-t-use-LIBDIR-as-variable.patch \
           file://run-ptest \
"